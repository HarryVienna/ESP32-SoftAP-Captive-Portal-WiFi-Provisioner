## sdkconfig.defaults
```kconfig
# Needed for ESP-IDF < 5.5.0
CONFIG_HTTPD_MAX_REQ_HDR_LEN=1024

CONFIG_LOG_DEFAULT_LEVEL_INFO=y
CONFIG_LOG_DEFAULT_LEVEL=4
```
